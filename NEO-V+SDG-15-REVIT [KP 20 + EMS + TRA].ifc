Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-03-09T12:04:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Mar 09 12:04:29 2019 * Host: FDev06 * Database: C:\Users\BALINT~1\AppData\Local\Temp\{CA6C7176-DB12-4A4B-A522-3466136738F7}\ifc * Database version: 5507 * Database creation date: Sat Mar 09 12:03:30 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Mar 09 12:03:30 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Mar 09 12:03:30 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=200:1932300
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=300:1932311
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=400:1932322
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=500:1932333
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=600:1932344
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=700:1932355
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=800:1932366
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=900:1932377
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1000. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=200:1932301
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=300:1932312
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=400:1932323
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=500:1932334
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=600:1932345
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=700:1932356
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=800:1932367
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=900:1932378
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1100. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=200:1932302
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=300:1932313
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=400:1932324
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=500:1932335
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=600:1932346
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=700:1932357
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=800:1932368
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=900:1932379
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=1200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=1000:1932380
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=1100:1932388
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=1200:1932396
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=200:1932292
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=300:1932303
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=400:1932314
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=500:1932325
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=600:1932336
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=700:1932347
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=800:1932358
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=900:1932369
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=1000:1932381
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=1100:1932389
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=1200:1932397
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=200:1932293
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=300:1932304
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=400:1932315
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=500:1932326
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=600:1932337
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=700:1932348
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=800:1932359
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=900:1932370
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=300. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=1000:1932382
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=1100:1932390
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=1200:1932398
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=200:1932294
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=300:1932305
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=400:1932316
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=500:1932327
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=600:1932338
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=700:1932349
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=800:1932360
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=900:1932371
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=400. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=1000:1932383
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=1100:1932391
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=1200:1932399
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=200:1932295
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=300:1932306
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=400:1932317
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=500:1932328
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=600:1932339
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=700:1932350
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=800:1932361
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=900:1932372
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=500. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=1000:1932384
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=1100:1932392
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=1200:1932400
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=200:1932296
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=300:1932307
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=400:1932318
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=500:1932329
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=600:1932340
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=700:1932351
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=800:1932362
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=900:1932373
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=600. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=1000:1932385
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=1100:1932393
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=1200:1932401
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=200:1932297
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=300:1932308
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=400:1932319
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=500:1932330
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=600:1932341
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=700:1932352
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=800:1932363
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=900:1932374
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=700. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=1000:1932386
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=1100:1932394
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=1200:1932402
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=200:1932298
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=300:1932309
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=400:1932320
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=500:1932331
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=600:1932342
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=700:1932353
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=800:1932364
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=900:1932375
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=800. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=1000:1932387
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=1100:1932395
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=1200:1932403
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=200:1932299
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=300:1932310
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=400:1932321
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=500:1932332
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=600:1932343
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=700:1932354
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=800:1932365
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=900:1932376
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 20 + EMS + SDG-15-24 + TRA, L=900. H=900
