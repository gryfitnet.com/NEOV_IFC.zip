Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-03-09T12:20:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Mar 09 12:20:35 2019 * Host: FDev06 * Database: C:\Users\BALINT~1\AppData\Local\Temp\{9913A8C7-1FA0-4ED5-BF76-22F9EC69D8FC}\ifc * Database version: 5507 * Database creation date: Sat Mar 09 12:19:38 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Mar 09 12:19:38 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Mar 09 12:19:38 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=200:1932524
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=300:1932535
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=400:1932546
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=500:1932557
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=600:1932568
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=700:1932579
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=800:1932590
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=900:1932601
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1000. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=200:1932525
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=300:1932536
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=400:1932547
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=500:1932558
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=600:1932569
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=700:1932580
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=800:1932591
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=900:1932602
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1100. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=200:1932526
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=300:1932537
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=400:1932548
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=500:1932559
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=600:1932570
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=700:1932581
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=800:1932592
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=900:1932603
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=1200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=1000:1932604
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=1100:1932612
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=1200:1932620
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=200:1932516
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=300:1932527
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=400:1932538
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=500:1932549
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=600:1932560
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=700:1932571
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=800:1932582
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=900:1932593
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=1000:1932605
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=1100:1932613
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=1200:1932621
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=200:1932517
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=300:1932528
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=400:1932539
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=500:1932550
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=600:1932561
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=700:1932572
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=800:1932583
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=900:1932594
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=300. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=1000:1932606
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=1100:1932614
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=1200:1932622
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=200:1932518
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=300:1932529
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=400:1932540
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=500:1932551
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=600:1932562
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=700:1932573
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=800:1932584
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=900:1932595
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=400. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=1000:1932607
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=1100:1932615
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=1200:1932623
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=200:1932519
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=300:1932530
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=400:1932541
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=500:1932552
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=600:1932563
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=700:1932574
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=800:1932585
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=900:1932596
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=500. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=1000:1932608
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=1100:1932616
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=1200:1932624
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=200:1932520
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=300:1932531
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=400:1932542
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=500:1932553
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=600:1932564
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=700:1932575
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=800:1932586
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=900:1932597
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=600. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=1000:1932609
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=1100:1932617
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=1200:1932625
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=200:1932521
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=300:1932532
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=400:1932543
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=500:1932554
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=600:1932565
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=700:1932576
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=800:1932587
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=900:1932598
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=700. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=1000:1932610
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=1100:1932618
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=1200:1932626
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=200:1932522
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=300:1932533
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=400:1932544
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=500:1932555
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=600:1932566
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=700:1932577
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=800:1932588
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=900:1932599
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=800. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=1000:1932611
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=1100:1932619
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=1200:1932627
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=200:1932523
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=300:1932534
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=400:1932545
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=500:1932556
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=600:1932567
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=700:1932578
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=800:1932589
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=900:1932600
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 30 + SDG-15-24 + TKA, L=900. H=900
