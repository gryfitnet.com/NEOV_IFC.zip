Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-03-09T12:16:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Mar 09 12:16:16 2019 * Host: FDev06 * Database: C:\Users\BALINT~1\AppData\Local\Temp\{EC48CE56-19DD-4F38-89D1-E32D107EB5E2}\ifc * Database version: 5507 * Database creation date: Sat Mar 09 12:15:17 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Mar 09 12:15:18 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Mar 09 12:15:18 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=200:1932188
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=300:1932199
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=400:1932210
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=500:1932221
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=600:1932232
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=700:1932243
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=800:1932254
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=900:1932265
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1000. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=200:1932189
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=300:1932200
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=400:1932211
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=500:1932222
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=600:1932233
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=700:1932244
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=800:1932255
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=900:1932266
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1100. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=200:1932190
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=300:1932201
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=400:1932212
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=500:1932223
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=600:1932234
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=700:1932245
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=800:1932256
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=900:1932267
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=1200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=1000:1932268
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=1100:1932276
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=1200:1932284
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=200:1932180
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=300:1932191
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=400:1932202
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=500:1932213
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=600:1932224
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=700:1932235
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=800:1932246
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=900:1932257
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=1000:1932269
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=1100:1932277
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=1200:1932285
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=200:1932181
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=300:1932192
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=400:1932203
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=500:1932214
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=600:1932225
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=700:1932236
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=800:1932247
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=900:1932258
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=300. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=1000:1932270
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=1100:1932278
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=1200:1932286
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=200:1932182
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=300:1932193
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=400:1932204
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=500:1932215
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=600:1932226
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=700:1932237
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=800:1932248
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=900:1932259
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=400. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=1000:1932271
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=1100:1932279
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=1200:1932287
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=200:1932183
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=300:1932194
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=400:1932205
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=500:1932216
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=600:1932227
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=700:1932238
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=800:1932249
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=900:1932260
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=500. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=1000:1932272
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=1100:1932280
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=1200:1932288
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=200:1932184
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=300:1932195
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=400:1932206
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=500:1932217
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=600:1932228
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=700:1932239
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=800:1932250
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=900:1932261
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=600. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=1000:1932273
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=1100:1932281
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=1200:1932289
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=200:1932185
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=300:1932196
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=400:1932207
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=500:1932218
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=600:1932229
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=700:1932240
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=800:1932251
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=900:1932262
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=700. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=1000:1932274
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=1100:1932282
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=1200:1932290
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=200:1932186
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=300:1932197
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=400:1932208
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=500:1932219
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=600:1932230
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=700:1932241
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=800:1932252
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=900:1932263
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=800. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=1000:1932275
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=1100:1932283
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=1200:1932291
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=200:1932187
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=300:1932198
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=400:1932209
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=500:1932220
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=600:1932231
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=700:1932242
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=800:1932253
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=900:1932264
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 20 + SDG-15-24 + TRA, L=900. H=900
