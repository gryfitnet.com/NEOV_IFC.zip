Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-03-09T12:10:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Mar 09 12:10:39 2019 * Host: FDev06 * Database: C:\Users\BALINT~1\AppData\Local\Temp\{CA924247-D141-484F-B2BC-6804B99EEC19}\ifc * Database version: 5507 * Database creation date: Sat Mar 09 12:09:38 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Mar 09 12:09:39 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Mar 09 12:09:39 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=200:1932972
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=300:1932983
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=400:1932994
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=500:1933005
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=600:1933016
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=700:1933027
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=800:1933038
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=900:1933049
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1000. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=200:1932973
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=300:1932984
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=400:1932995
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=500:1933006
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=600:1933017
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=700:1933028
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=800:1933039
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=900:1933050
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1100. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=200:1932974
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=300:1932985
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=400:1932996
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=500:1933007
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=600:1933018
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=700:1933029
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=800:1933040
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=900:1933051
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=1200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=1000:1933052
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=1100:1933060
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=1200:1933068
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=200:1932964
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=300:1932975
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=400:1932986
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=500:1932997
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=600:1933008
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=700:1933019
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=800:1933030
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=900:1933041
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=1000:1933053
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=1100:1933061
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=1200:1933069
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=200:1932965
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=300:1932976
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=400:1932987
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=500:1932998
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=600:1933009
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=700:1933020
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=800:1933031
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=900:1933042
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=300. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=1000:1933054
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=1100:1933062
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=1200:1933070
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=200:1932966
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=300:1932977
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=400:1932988
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=500:1932999
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=600:1933010
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=700:1933021
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=800:1933032
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=900:1933043
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=400. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=1000:1933055
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=1100:1933063
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=1200:1933071
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=200:1932967
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=300:1932978
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=400:1932989
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=500:1933000
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=600:1933011
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=700:1933022
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=800:1933033
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=900:1933044
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=500. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=1000:1933056
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=1100:1933064
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=1200:1933072
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=200:1932968
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=300:1932979
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=400:1932990
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=500:1933001
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=600:1933012
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=700:1933023
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=800:1933034
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=900:1933045
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=600. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=1000:1933057
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=1100:1933065
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=1200:1933073
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=200:1932969
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=300:1932980
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=400:1932991
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=500:1933002
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=600:1933013
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=700:1933024
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=800:1933035
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=900:1933046
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=700. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=1000:1933058
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=1100:1933066
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=1200:1933074
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=200:1932970
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=300:1932981
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=400:1932992
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=500:1933003
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=600:1933014
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=700:1933025
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=800:1933036
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=900:1933047
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=800. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=1000:1933059
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=1100:1933067
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=1200:1933075
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=200:1932971
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=300:1932982
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=400:1932993
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=500:1933004
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=600:1933015
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=700:1933026
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=800:1933037
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=900:1933048
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 30 + EMS + SDG-15-24 + TRA, L=900. H=900
