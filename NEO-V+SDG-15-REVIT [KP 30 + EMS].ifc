Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-03-09T12:11:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Mar 09 12:11:49 2019 * Host: FDev06 * Database: C:\Users\BALINT~1\AppData\Local\Temp\{83F6B104-F359-4C31-92B4-2C71770AB88E}\ifc * Database version: 5507 * Database creation date: Sat Mar 09 12:11:45 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Mar 09 12:11:45 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Mar 09 12:11:45 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=200:1932636
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=300:1932647
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=400:1932658
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=500:1932669
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=600:1932680
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=700:1932691
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=800:1932702
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=900:1932713
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1000x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1000. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=200:1932637
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=300:1932648
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=400:1932659
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=500:1932670
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=600:1932681
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=700:1932692
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=800:1932703
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=900:1932714
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1100x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1100. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=200:1932638
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=300:1932649
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=400:1932660
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=500:1932671
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=600:1932682
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=700:1932693
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=800:1932704
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=900:1932715
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=1200x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=1200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=1000:1932716
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=1100:1932724
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=1200:1932732
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=200:1932628
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=300:1932639
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=400:1932650
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=500:1932661
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=600:1932672
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=700:1932683
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=800:1932694
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=900:1932705
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=200x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=200. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=1000:1932717
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=1100:1932725
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=1200:1932733
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=200:1932629
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=300:1932640
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=400:1932651
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=500:1932662
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=600:1932673
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=700:1932684
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=800:1932695
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=900:1932706
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=300x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=300. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=1000:1932718
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=1100:1932726
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=1200:1932734
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=200:1932630
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=300:1932641
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=400:1932652
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=500:1932663
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=600:1932674
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=700:1932685
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=800:1932696
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=900:1932707
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=400x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=400. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=1000:1932719
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=1100:1932727
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=1200:1932735
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=200:1932631
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=300:1932642
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=400:1932653
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=500:1932664
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=600:1932675
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=700:1932686
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=800:1932697
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=900:1932708
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=500x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=500. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=1000:1932720
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=1100:1932728
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=1200:1932736
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=200:1932632
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=300:1932643
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=400:1932654
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=500:1932665
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=600:1932676
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=700:1932687
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=800:1932698
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=900:1932709
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=600x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=600. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=1000:1932721
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=1100:1932729
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=1200:1932737
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=200:1932633
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=300:1932644
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=400:1932655
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=500:1932666
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=600:1932677
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=700:1932688
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=800:1932699
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=900:1932710
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=700x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=700. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=1000:1932722
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=1100:1932730
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=1200:1932738
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=200:1932634
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=300:1932645
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=400:1932656
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=500:1932667
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=600:1932678
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=700:1932689
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=800:1932700
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=900:1932711
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=800x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=800. H=900

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=1000, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=1000:1932723
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1000, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=1000

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=1100, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=1100:1932731
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1100, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=1100

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=1200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=1200:1932739
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x1200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=1200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=200, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=200:1932635
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x200, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=200

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=300, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=300:1932646
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x300, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=300

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=400, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=400:1932657
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x400, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=400

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=500, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=500:1932668
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x500, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=500

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=600, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=600:1932679
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x600, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=600

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=700, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=700:1932690
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x700, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=700

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=800, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=800:1932701
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x800, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=800

# IfcBuildingElementProxy: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=900, GRYFIT NEO-V, Multiblade smoke control damper NEO-V:GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=900:1932712
In: Level 1
Pset_BuildingElementProxyCommon - Reference: GRYFIT NEO-V, LxH=900x900, Galvanized steel, KP 30 + EMS + SDG-15-24, L=900. H=900
